## lpc3xxx/linux-2.6.33-lpc313x/drivers/xode/Kconfig
```kconfig
#
# Zorro configuration
#
config XODE
	bool "Xode device driver"
#	depends on ZORRO
	---help---
	  When in doubt, say Y.
```
